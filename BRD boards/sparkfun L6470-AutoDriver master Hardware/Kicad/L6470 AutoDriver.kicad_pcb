# Repository PCBench/PCBench

File README.md:

# PCBench: A Dataset for Printed Circuit Board Routing
PCBench is a dataset for PCB routing task, it includes a dataset consisting of 164 printed circuit boards (PCB), a data augmentation script  to expand the dataset for supervised learning (SL) tasks, and a reinforcement learning (RL) environment.

## Dataset
### Folder Structure
All the PCB designs in our dataset are stored in the folder `PCBs`, where each PCB design is stored in a subfolder named `{author/org}_{PCB_name}_{design_version(optional)}`. Below is the folder structure of the dataset.
```
├── PCBs
│   ├── master_metadata.json
│   ├── subfolder1
│   │   ├── raw.kicad_pcb
│   │   ├── processed.kicad_pcb
│   │   ├── final.json
│   │   ├── metadata.json
│   │   ├── visual.png
│   ├── subfolder2
│   │   ├── raw.kicad_pcb
│   │   ├── processed.kicad_pcb
│   │   ├── final.json
│   │   ├── metadata.json
│   │   ├── visual.png
│   ├── ...
```
The `raw.kicad_pcb` is the raw PCB design file, `process.kicad_pcb` is the file after cleaning up, `final.json` stores only  routing-related information used for ML tasks. `metadata.json` stores the meta information for each single PCB design. `visual.png` is a visualization of each single PCB design. `master_meta.json` contains metadata of all PCBs and global-level information.

### PCB Routing Description Language (PCB-RDL)
We propose a JSON specification (`final.json` for each PCB design) called the PCB Routing Description  Language (PCB-RDL) that expresses a PCB routing problem and its solutions intuitively using basic concepts in order to facilitate research into automated PCB routing using ML. Following figure shows is an example of PCB with marked components in PCB-RDL (Left) and it corrsponding PCB-RDL (Right).

## Data Augmentation
### Run
The augmentation data can be generated with the script [`Scripts/Data_augmentation/augmentation.py`](https://github.com/PCBench/PCBench/blob/main/Scripts/Data_augmentation/augmentation.py).  To generate 3 samples by randomly extracting 50% nets from the PCB `1Bitsy_1bitsy`, please run the following command
```
cd Scripts/Data_augmentation/
python augmentation.py --num_samples 3 --net_ratio 0.5 --pcb_name 1Bitsy_1bitsy
```
### Output
All the generated PCBs will be stored in the folder named `augmented_data` under  `Scripts/Data_augmentation/`. In `augmented_data`, all the generated samples will be stored in a subfolder with the name of selected PCB. Each generated sample has the name `sample_index.json`. For example, the above command will generate the following file under `Scripts/Data_augmentation/`
```
├── augmented_data
│   ├── 1Bitsy_1bitsy
│   │   ├── 1.json
│   │   ├── 2.json
│   │   ├── 3.json
```

## RL environment

### Installation
The RL environment requires Python >= 3.7. You can simply install the environment with the following commands:
```
git clone https://github.com/PCBench/PCBench.git
cd PCBench
python setup.py install
```
After installation, open a Python console and type
```
from RLEnv.EnvLayer.PCBRoutingEnv import PCBRoutingEnv
```
If no error occurs, you have successfully installed the PCB routing environment.

### API Usage
The following content shows an example of API usage of PCBRoutingEnv. 
```
from RLEnv.EnvLayer.PCBRoutingEnv import PCBRoutingEnv
import random

resolution = [0.5, 0.5]
pcb_folder = '../PCBs/'
pcb_names = ["1Bitsy_1bitsy"]
iters = 30
env = PCBRoutingEnv(resolution=resolution, pcb_folder=pcb_folder, pcb_names=pcb_names)
obs, info = env.reset()
for _ in range(iters):
    act = random.randint(0,5)
    obs, rew, terminal, _, info = env.step(act)
    if terminal:
        env.reset()
```
You can find more examples of customizing functions of reward and state observation from [RLEnv/examples.ipynb](https://github.com/PCBench/PCBench/blob/main/RLEnv/examples.ipynb).

## KiCad design BRD boards/sparkfun L6470-AutoDriver master Hardware/Kicad/L6470 AutoDriver.kicad_pcb

File BRD boards/README.md:

## BRD Files

This is the root directory for a collection of subdirectories containing PCBs from Sparkfun. I've taken the liberty of using the KiCad software to import these projects from EAGLE CAD. The files generated from the import process are contained in a subdirectory of each project called `Kicad/`. I've also ran the cleaning script on the `.kicad_pcb` files generated by the import process, so a `processed.kicad_pcb` file is also present in these directories.

The import process appears to consistently produce a few types of errors:
1. Unrouted nets are present in the boards. Some nets *may be* genuinely unrouted (manual review of these limited number of boards does not indicate this, however), but often it appears that there are little "stubs" that lie along the same plane as a fully routed trace. As far as I can tell, it's like it laid the same wire twice, but didn't finish one. These do not seem to be a big concern, and should be reliably removed by cleaning script, along with any *true* unrouted nets.
2. There are layers used by EAGLE that are not supported by KiCad (e.g. 'Keepout' layers). An alert window in the KiCad software indicates that they have been converted to 'User' layers after the import finished.
3. There are DRC errors present in some boards. Common examples include "track too close to copper item" and "Pad too close to pad". These are left unresolved even post cleaning.

Parts:
C1: 0.1uF; 0603-CAP
C2: 10uF; EIA3216
C3: 100uF; NIC_10X10.5_CAP
C4, C5: 0.22uF; 0603-CAP
C6, C7: 10nF; 0603-CAP
C8: 47uF; EIA3528
D1: BAV99; SOT23-3
FID1, FID2: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
JP1, JP2: M05X2SHD; 2X5-SHROUDED
JP3, JP4: M03X2SHROUD; 2X3-SHROUDED
JP5, JP6, JP7, JP8, JP9: M023.5MM; SCREWTERMINAL-3.5MM-2
LOGO1: OSHW-LOGOM; OSHW-LOGO-M
LOGO2: SFE_LOGO_NAME_FLAME.2_INCH; SFE_LOGO_NAME_FLAME_.2
R1, R2: 10k; 0603-RES
R3: 100; 0603-RES
R4: 200k; 3362U
R5: 8.2k; 0603-RES
R6: 33k; 0603-RES
SJ1, SJ3: JUMPER-PAD-3-2OF3_NC_BY_PASTE; PAD-JUMPER-3-2OF3_NC_BY_PASTE_YES_SILK_FULL_BOX
SJ2: 2PT_GND_TIE
STANDOFF1, STANDOFF2, STANDOFF3, STANDOFF4: STAND-OFF
TP1: TEST-POINTTP_15TH_THRU; TP_15TH
U1: L6470; HTSSOP28
U$4: FOUR_LAYER_WARNING

Connections:
3.3V: C8.A (+), SJ1.1, TP1.P$1, U1.6 (VREG)
5V: JP1.1, JP1.10, JP2.1, JP2.10, SJ1.3
/ADC: R4.P$2 (S), R4.P$3 (A), R5.2, U1.5 (ADCIN)
/BUSYN: JP3.2, JP4.2, R1.1, U1.22 (BUSYN/SYNC)
/CSN: JP1.3, JP2.3, U1.23 (CSN)
/D_RETURN: JP1.4, JP2.4, SJ3.3
/FLAGN: JP3.3, JP4.3, R2.1, U1.24 (FLAGN)
/OSCIN: JP1.7, JP1.8, U1.7 (OSCIN)
/OSCOUT: JP2.7, JP2.8, U1.8 (OSCOUT)
/OUT1A: JP8.2, U1.1 (OUT1A)
/OUT1B: JP9.1, U1.14 (OUT1B)
/OUT2A: JP8.1, U1.28 (OUT2A)
/OUT2B: JP9.2, U1.15 (OUT2B)
/PGND: C3.-, C4.2, JP7.1, JP7.2, SJ2.P$2, U1.13 (PGNDB), U1.27 (PGNDA), U1.29 (EPAD)
/RESETN: JP3.1, JP4.1, U1.3 (STBYN/RESETN)
/SCK: JP1.6, JP2.6, U1.19 (CK)
/SDI: JP1.5, U1.20 (SDI)
/SDO: SJ3.2, U1.18 (SDO)
/SDO_DOWNSTREAM: JP2.5, SJ3.1
/STCK: JP3.6, JP4.6, U1.25 (STCK)
/VLOGIC: C1.1, C2.A (+), R1.2, R2.2, SJ1.2, U1.17 (VDD)
GND: C1.2, C2.C (-), C7.2, C8.C (-), JP1.2, JP1.9, JP2.2, JP2.9, JP3.5, JP4.5, JP5.2, R5.1, SJ2.P$1, U1.9 (AGND), U1.21 (DGND)
unnamed: C5.1, D1.2 (C2), U1.11 (VBOOT)
unnamed: C6.1, D1.3 (COM)
unnamed: C6.2, U1.10 (CP)
unnamed: C7.1, JP5.1, R3.2
unnamed: R3.1, U1.4 (SW)
unnamed: R4.P$1 (E), R6.1
VCC: C3.+, C4.1, C5.2, D1.1 (A1), JP6.1, JP6.2, R6.2, U1.2 (VSA), U1.12 (VSB), U1.16 (VSB2), U1.26 (VSA2)

Notes on the sheet:
63V
Switch Input
B-Coil
A-Coil
Supply Connector
Ground Connector
SJ1 allows user to select external power over comm headers or internal 3.3V power. NB- DO NOT connect external power to JP1 or JP2 when internal supply is selected~
Next Board
Prev Board/ Controller
Meta Out
Meta In
ADC is 5-bit 0-3.3V range. R4 should be populated with a 200k pot for supply voltage compensation; see datasheet p36 for details.
SPI Data is MSB first, SPI mode 3: CPOL=CPHA=1 5 Mbit max
Mike Hord
Vs must be between 8V and 45V Motor supply must be enabled for chip comms to work~
SJ3 allows you to route the SDO (serial data out) either to the next board (if this board is in a chain) or back to the previous board (if this board is the last or only board in the chain). It defaults to back to previous board, for single board applications.

Board: 4 copper layers, 73.7 x 49.5 mm, 39 parts (0 on the bottom side), 29 nets.

## KiCad design BRD boards/sparkfun OpenPIR master Hardware/Kicad/SparkFun-OpenPIR-NCS36000.kicad_pcb

Parts:
C1, C3: 22uF; 0805
C2, C4: 10nF; 0603
C5, C6, C7: 0.1uF; 0603
D1: Green; LED-1206-BOTTOM
FD1, FD2: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
H1, H2, H3, H4: STAND-OFF
J2: CONN_04JST-PTH-VERT-NS; JST-4-PTH-VERT-NS
J8: CONN_04NO_SILK_ALL_ROUND; 1X04_NO_SILK_ALL_ROUND
LOGO1: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
LOGO3: SFE_LOGO_NAME.1_INCH; SFE_LOGO_NAME_.1
LOGO4: OSHW-LOGOS; OSHW-LOGO-S
R1, R3: 10k; 0603
R2: 560k; 0603
R4, R7: 1M; TRIMPOT-TC33X
R5: 43k; 0603
R6: 51k; 0603
R8: 1k; 0603
S1: SWITCH-SPDT-SMD-A; SWITCH-SPST-SMD-A
SJ1: LED-EN; SJ_2S
TP1, TP2: TEST-POINT3X5; PAD.03X.05
U1: NCS36000; SO14
U2: PIR
U$1: CWM 0.5 GI V1; LENS-CWM-0.5-GI-V1

Connections:
/A_OUT: C4.2, J2.1, J8.1, R4.1 (CCW), U1.1 (OP2_O)
/LED: R8.1, U1.9 (LED)
/MODE: S1.2, U1.12 (MODE)
/OUT: J2.4, J8.4, U1.8 (OUT)
/~LED_EN~: SJ1.1, U1.10 (~LED_EN~)
GND: C5.2, C6.2, C7.2, J2.3, J8.3, R1.1, R5.1, S1.3 (S), SJ1.2, U1.7 (VSS), U2.G
unnamed: C1.1, C2.2, R2.1, U1.4 (OP1_N)
unnamed: C1.2, R1.2
unnamed: C2.1, C3.1, R2.2, U1.3 (OP1_O)
unnamed: C3.2, R3.2
unnamed: C4.1, R3.1, R4.2 (WIPER), R4.3 (CW), TP1.P$1, U1.2 (OP2_N)
unnamed: C5.1, R5.2, U1.5 (OP1_P), U2.S
unnamed: C6.1, U1.6 (VREF), U2.D
unnamed: C7.1, R6.1, U1.13 (OSC)
unnamed: D1.C, R8.2
unnamed: R6.2, R7.1 (CCW)
VCC: D1.A, J2.2, J8.2, R7.2 (WIPER), R7.3 (CW), TP2.P$1, U1.14 (VDD)

Notes on the sheet:
The ~LED_EN~ pin enables the LED output when motion has been detected. It's active-low. During start-up the LED will toggle regardless of ~LED_EN~'s state.
MODE selects the pulse-count mode. * Single-pulse (MODE=LOW): OUT will trigger if either comparator toggles and deglitch time is appropriate length. * Dual-pulse (MODE=Vdd): Requires two pulses - one from each comparator - within 312 clock cycles.
Jim Lindblom
v10
VCC Range: 3.0 - 5.75V
The NCS36000 features a 2-stage amplifier - gain and passband are set by passive components R1-R4 & C1-C4. E.g. R1=R3=10k, R2=R4=560k, C1=C3=33uF, C2=C4=10nF creates a 70dB passband gain with cutoff frequencies around 700mHz and 20Hz. Subbing a potentiometer in for R4 enables dymanic selection of t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
C7, R6, and R7 set the oscillator frequency of the NCS36000. E.g.: C7=100nF, R6+R7=220k, Osc Freq = 62.5 Hz. Higher resistance = higher frequency
ZCWM05GIV1 - Ceiling mount array 360° oval or wall mount array 100°, 8m range. Wall or ceiling mount for medium room
PIR and NCS36000 Amplifier
Connectors
Single/Dual Pulse Mode Select
LED Activity Indicator
Lens

Board: 2 copper layers, 27.9 x 35.6 mm, 35 parts (0 on the bottom side), 17 nets.

## KiCad design PCBs/guitar_fret/processed.kicad_pcb

File PCBs/README.md:

# Dataset of PCB designs
This folder stores all the PCB design (each design is stored in a folder, please refer to this [doc](https://pcbench.slab.com/public/posts/file-hierarchy-imdkde4b) for details of folder name and structure) including the raw files (kicad and eagle files) that we scrape directly from different sources, the cleaned files and stored in kicak format, and final JSON files that we use to store routing informations that can be used for ML tasks. [This repo](https://github.com/SergioGasquez/awesome-electronic-engineering#kicad) list learning resources for PCB or electronic designs. 

## find and upload PCB designs

To upload the circuit to this folder, please
1. upload the found circuit from different sources and store it in a folder (refer to this [doc](https://pcbench.slab.com/public/posts/file-hierarchy-imdkde4b) for details). Please refer this [doc](https://docs.google.com/document/d/10nzUBFvauhISvmaXDbtiUpjhvJx0_DutUYc8_EI8eA8/edit) about where to find the circuit.
2. go to `/PCBench/Scripts/Data_cleaning` and run `python PCB_cleaner.py kicad_file_path`. It will output a `processed.kicad_pcb` file to the folder where the raw file is stored. Note that the clean-up script currently only works for kicad files. For eagle files, just ignore this and following steps for now.
3. open the cleaned-up `processed.kicad_pcb` file and check if the clean up is correct. Please refer to this [issue](https://github.com/ybiao-he/PCBench/issues/1) about criterias of correctness.

Note that 
1. if the souce file is from KiCAD version 5, please put `.kicad_pcb` file in the folder, and if the source file is from KiCAD version 6, please put `.kicad_pcb` and `.pro` file in the folder. 
2. if you meet any issues when uploading PCB designs or run our scripts for cleaning up the data, please report the issue to [github issues of this repo](https://github.com/ybiao-he/PCBench/issues).

Board: 2 copper layers, 65.0 x 25.0 mm, 51 parts (39 on the bottom side), 32 nets.

Parts:
C0, C1, C2, C3, C4, C5, C6, C7, C8, C11: 100nF; C_0603
C9, C10: 22uF; C_0805
C12, C13: 47nF; C_0603
J1: +5V; IDC-1x1
J2: GNDPWR; IDC-1x1
J3: +3.3V; IDC-1x1
J4: GND; IDC-1x1
J5: SDA; IDC-1x1
J6: SCL; IDC-1x1
J7: BOOT0; pad-2mm-round
J8: NRST; pad-2mm-round
J9: SWDIO; pad-2mm-round
J10: CONN_01X06; Connector_Molex_PicoBlade_53261-0671
J11: SWCLK; pad-2mm-round
JP1: GNDPWR-GND; R_0603
JP2: SPI-CONNECTION; R_0603
LED0, LED1, LED2, LED3, LED4, LED5: WS2812; 5050-6pin
P0, P1, P2, P3, P4, P5: TOUCH; TP-8x15
R0, R1, R2, R3, R4, R5, R6, R12: 10k; R_0603
R7, R8: 4.7k; R_0603
U1: STM32F051K*T; LQFP-32_7x7mm_Pitch0.8mm
U2: AP2210N-3.3TRG1; SOT-23

Connections:
+3V3: C0.1, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, J3.1, J10.1, LED0.3, LED1.3, LED2.3, LED3.3, LED4.3, LED5.3, R6.2, R7.1, R8.1, U1.1, U1.5, U1.17, U2.2
+5V: C9.1, J1.1, LED0.5, LED1.5, LED2.5, LED3.5, LED4.5, LED5.5, U2.3
/BOOT0: J7.1, R12.2, U1.31
/BUTTON: J10.6, LED4.1, LED5.2, U1.12
/CG1: C12.1, U1.9
/CG4: C13.1, U1.22
/LED0: LED0.2, U1.13
/LED1: LED0.1, LED1.2
/LED2: LED1.1, LED2.2
/LED3: LED2.1, LED3.2
/LED4: LED3.1, LED4.2
/LED6: J10.5, LED5.1, U1.11
/MISO: JP2.1, U1.27, U1.28
/NRST: C11.1, J8.1, R6.1, U1.4
/P0: R0.1, U1.6
/P1: R1.1, U1.7
/P2: R2.1, U1.8
/P3: R3.1, U1.19
/P4: R4.1, U1.20
/P5: R5.1, U1.21
/SCK: J6.1, J10.3, R8.2, U1.26, U1.29
/SDA: J5.1, J10.2, JP2.2, R7.2, U1.30
/SWCLK: J11.1, U1.24
/SWDIO: J9.1, U1.23
GND: C0.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, J4.1, J10.4, JP1.2, R12.1, U1.16, U1.32, U2.1
GNDPWR: C9.2, J2.1, JP1.1, LED0.6, LED1.6, LED2.6, LED3.6, LED4.6, LED5.6
unnamed: P0.1, R0.2
unnamed: P1.1, R1.2
unnamed: P2.1, R2.2
unnamed: P3.1, R3.2
unnamed: P4.1, R4.2
unnamed: P5.1, R5.2

## KiCad design PCBs/Practicas-Curso-Kicad_Ejercicio_2/processed.kicad_pcb

Board: 2 copper layers, 40.6 x 60.9 mm, 14 parts (2 on the bottom side), 22 nets.

Parts:
C1, C2, C3, C4, C5, C6: 100nf; C_1206_HandSoldering
G101: Logo_OSHWA
J1: DB9; DB9_F_TH
JP1: CONN_3; CON_PALETA_3
R1, R2: 60; R_1206_HandSoldering
U1: AMIS42665TJAA1RG; SOIC-8
U2: SP-232v2; SP3232ECN-SOIC16N
XA1: Conn_Poncho2P_2x_20x2; Conn_Poncho_Derecha

Connections:
+3.3V: C4.2, U2.16, XA1.1
+5V: C1.2, U1.3, XA1.2
/Conector y Can/CAN_N: JP1.2, R2.2, U1.6
/Conector y Can/CAN_P: JP1.1, R1.1, U1.7
/Conector y Can/CAN_RX: U1.4, XA1.27
/Conector y Can/CAN_TX: U1.1, XA1.29
/Conector y Can/CTS: U2.10, XA1.37
/Conector y Can/RTS: U2.9, XA1.35
/Conector y Can/RXD: U2.11, XA1.25
/Conector y Can/TXD: U2.12, XA1.23
GND: C1.1, C4.1, C5.1, C6.1, J1.5, JP1.3, U1.2, U1.8, U2.15, XA1.4, XA1.20, XA1.22, XA1.24, XA1.26, XA1.28, XA1.30, XA1.32, XA1.38, XA1.40
unnamed: C2.1, U2.1
unnamed: C2.2, U2.3
unnamed: C3.1, U2.4
unnamed: C3.2, U2.5
unnamed: C5.2, U2.2
unnamed: C6.2, U2.6
unnamed: J1.2, U2.14
unnamed: J1.3, U2.13
unnamed: J1.7, U2.8
unnamed: J1.8, U2.7
unnamed: R1.2, R2.1, U1.5

## KiCad design PCBs/arduino-led-driver_arduino-led-driver/processed.kicad_pcb

Board: 2 copper layers, 70.0 x 44.0 mm, 118 parts (30 on the bottom side), 77 nets.

Parts:
C1: 330n; C_0805
C2, C3, C12: 100n; C_0805
C4, C5, C6, C7: 2.2u; C_0805
C8, C9, C10, C11: 1u; C_0805
D1: LED; LED-3MM
D2, D3, D4, D5: DFLS240L; POWERDI-123
ICSP1: AVR-ISP-6; Pin_Header_Straight_2x03
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22: CONN_01X02; Socket_Strip_Straight_1x02
L1, L2, L3, L4: 33u; VLP8040
Noname_1: Symbol_OSHW-Logo_SilkScreen
PWR1: BARREL_JACK
R1, R2, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42: 100K; R_0805
R3, R4, R5, R6: 130m; R_0805
R43: 10K; R_0805
R44, R45, R46, R47: 2.2K; R_0805
R48: 10k; R_0805
U1: ATMEGA328P-A; TQFP-32_7x7mm_Pitch0.8mm
U2: L78L05ACD; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3, U4, U5, U6: AL8808; SOT-23-5
U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24: BCR420UW6; SOT-23-6

Connections:
+5V: C2.1, C3.1, ICSP1.2, R43.1, R48.1, U1.4, U1.6, U1.18, U2.1
+12V: C1.1, C4.1, C5.1, C6.1, C7.1, D2.1, D3.1, D4.1, D5.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, PWR1.1, R3.2, R4.2, R5.2, R6.2, U2.8, U3.5, U4.5, U5.5, U6.5
EN1: R7.1, U1.12, U7.1
EN2: ICSP1.4, R8.1, U1.15, U8.1
EN3: ICSP1.1, R9.1, U1.16, U9.1
EN4: ICSP1.3, R10.1, U1.17, U10.1
EN5: R11.1, U1.7, U11.1
EN6: R12.1, U1.8, U12.1
EN7: R13.1, U1.23, U13.1
EN8: R14.1, U1.24, U14.1
EN9: R15.1, U1.25, U15.1
EN10: R16.1, U1.26, U16.1
EN11: R17.1, U1.27, U17.1
EN12: R18.1, U1.28, U18.1
EN13: R19.1, U1.30, U19.1
EN14: R20.1, U1.31, U20.1
EN15: R21.1, U1.32, U21.1
EN16: R22.1, U1.1, U22.1
EN17: R23.1, U1.2, U23.1
EN18: R24.1, U1.11, U24.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C12.2, D1.1, ICSP1.6, PWR1.2, PWR1.3, R1.2, R2.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R44.2, R45.2, R46.2, R47.2, U1.3, U1.5, U1.21, U2.2, U2.3, U2.6, U2.7, U3.2, U4.2, U5.2, U6.2, U7.4, U8.4, U9.4, U10.4, U11.4, U12.4, U13.4, U14.4, U15.4, U16.4, U17.4, U18.4, U19.4, U20.4, U21.4, U22.4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
unnamed: C8.1, J1.1, R3.1, U3.4
unnamed: C8.2, J1.2, L1.1
unnamed: C9.1, J2.1, R4.1, U4.4
unnamed: C9.2, J2.2, L2.1
unnamed: C10.1, J3.1, R5.1, U5.4
unnamed: C10.2, J3.2, L3.1
unnamed: C11.1, J4.1, R6.1, U6.4
unnamed: C11.2, J4.2, L4.1
unnamed: C12.1, ICSP1.5, R48.2, U1.29
unnamed: D1.2, R43.2
unnamed: D2.2, L1.2, U3.1
unnamed: D3.2, L2.2, U4.1
unnamed: D4.2, L3.2, U5.1
unnamed: D5.2, L4.2, U6.1
unnamed: J5.2, U7.2, U7.3, U7.5
unnamed: J6.2, U8.2, U8.3, U8.5
unnamed: J7.2, U9.2, U9.3, U9.5
unnamed: J8.2, U10.2, U10.3, U10.5
unnamed: J9.2, U11.2, U11.3, U11.5
unnamed: J10.2, U12.2, U12.3, U12.5
unnamed: J11.2, U13.2, U13.3, U13.5
unnamed: J12.2, U14.2, U14.3, U14.5
unnamed: J13.2, U15.2, U15.3, U15.5
unnamed: J14.2, U16.2, U16.3, U16.5
unnamed: J15.2, U17.2, U17.3, U17.5
unnamed: J16.2, U18.2, U18.3, U18.5
unnamed: J17.2, U19.2, U19.3, U19.5
unnamed: J18.2, U20.2, U20.3, U20.5
unnamed: J19.2, U21.2, U21.3, U21.5
unnamed: J20.2, U22.2, U22.3, U22.5
unnamed: J21.2, U23.2, U23.3, U23.5
unnamed: J22.2, U24.2, U24.3, U24.5
unnamed: R1.1, U1.19
unnamed: R2.1, U1.22
unnamed: R25.1, U7.6
unnamed: R26.1, U8.6
unnamed: R27.1, U9.6
unnamed: R28.1, U10.6
unnamed: R29.1, U11.6
unnamed: R30.1, U12.6
unnamed: R31.1, U13.6
unnamed: R32.1, U14.6
unnamed: R33.1, U15.6
unnamed: R34.1, U16.6
unnamed: R35.1, U17.6
unnamed: R36.1, U18.6
unnamed: R37.1, U19.6
unnamed: R38.1, U20.6
unnamed: R39.1, U21.6
unnamed: R40.1, U22.6
unnamed: R41.1, U23.6
unnamed: R42.1, U24.6
unnamed: R44.1, U1.9, U6.3
unnamed: R45.1, U1.13, U3.3
unnamed: R46.1, U1.10, U5.3
unnamed: R47.1, U1.14, U4.3

## KiCad design PCBs/HES-V2_hes/processed.kicad_pcb

Board: 2 copper layers, 115.0 x 45.0 mm, 16 parts (2 on the bottom side), 11 nets.

Parts:
D1: LED; LED-5MM-3
Noname_1, Noname_2, Noname_3, Noname_4: 1pin
P1, P2: CONN_01X15; Pin_Header_Straight_1x15
R1: Resistor; Resistor_Horizontal_RM10mm
SW1, SW2, SW3, SW4, SW5, SW6: SW_PUSH; SW_TH_Tactile_Omron_B3F-10xx
SW7, SW8: SW_PUSH; B3F-4000

Connections:
/A: P1.9, SW8.1
/B: P2.8, SW7.1
/D: P1.8, SW3.1, SW3.2
/L: P1.4, SW1.1
/LED: D1.2, P2.3
/R: P1.7, SW4.1, SW4.2
/SL: P2.1, SW5.1, SW5.2
/ST: P2.6, SW6.1, SW6.2
/U: P1.6, SW2.1
GND: P1.14, P2.12, R1.2, SW1.3, SW1.4, SW2.3, SW2.4, SW3.3, SW3.4, SW4.3, SW4.4, SW5.3, SW5.4, SW6.3, SW6.4, SW7.2, SW8.2
unnamed: D1.1, R1.1

Notices in the files:
parts and their libraries:
https://creativecommons.org/licenses/by-sa/4.0
Released under the Creative Commons Attribution Share-Alike 4.0 License
