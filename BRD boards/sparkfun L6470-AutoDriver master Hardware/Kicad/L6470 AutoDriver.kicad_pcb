# Repository PCBench/PCBench (continued)

## KiCad design PCBs/clunet-switch1_switch/processed.kicad_pcb

Board: 2 copper layers, 41.4 x 40.0 mm, 36 parts (0 on the bottom side), 37 nets.

Parts:
C2: 10mkf; C_1206_HandSoldering
C5: C_Small; C_1206_HandSoldering
D1, D2, D3: Led1; LED_D5.0mm-4-LL
D4, D5, D6: AH201; TO-92_Inline_Wide
IC1: ATMEGA8A-A; TQFP-32_7x7mm_Pitch0.8mm-LUT
P2: Reset; Measurement_Point_Round-SMD-Pad_Small
P3: Vcc; Socket_Strip_Straight_1x01_Pitch2.54mm
P4: Gnd; Socket_Strip_Straight_1x01_Pitch2.54mm
P7: Clunet; Socket_Strip_Straight_1x01_Pitch2.54mm
P8: CON_MOS; Measurement_Point_Round-SMD-Pad_Small
P11: R1_; Socket_Strip_Straight_1x02_Pitch2.54mm
P12: R2_; Socket_Strip_Straight_1x02_Pitch2.54mm
P15: CON_MIS; Measurement_Point_Round-SMD-Pad_Small
P16: CON_SCK; Measurement_Point_Round-SMD-Pad_Small
P17: Vcc_Prog; Measurement_Point_Round-SMD-Pad_Small
P18: Gnd_Prog; Measurement_Point_Round-SMD-Pad_Small
P19: SPK; Socket_Strip_Straight_1x02_Pitch2.54mm
Q1: PNP BC858; SOT-23
R1: 1.5K; R_1206_HandSoldering
R2, R6: 470R; R_1206_HandSoldering
R3, R4, R7, R8, R11, R12, R13: 470R; R_0805_HandSoldering
R5: 2.2K; R_0805_HandSoldering
R9: 22K; R_0805_HandSoldering
R10: 560R; R_0805_HandSoldering
U2: ULN2003-norm; SO-16-N

Connections:
/LED1_1: IC1.14, R2.2
/LED1_2: IC1.13, R4.2
/LED1_3: IC1.12, R3.2
/LED2_1: IC1.17, P16.1, R11.2
/LED2_2: IC1.23, R12.2
/LED2_3: IC1.24, R13.2
/LED3_1: IC1.26, R6.2
/LED3_2: IC1.27, R8.2
/LED3_3: IC1.28, R7.2
/R1_1: IC1.11, U2.1
/R1_2: IC1.10, U2.2
/R2_1: IC1.9, U2.3
/R2_2: IC1.8, U2.4
/SW1: D4.3, IC1.15, P8.1
/SW2: D5.3, IC1.16, P15.1
/SW3: D6.3, IC1.25
/spk: IC1.7, U2.7
GND: C2.2, C5.2, D1.2, D2.2, D3.2, D4.2, D5.2, D6.2, IC1.3, IC1.5, IC1.21, P4.1, P18.1, Q1.3, U2.8
unnamed: D1.1, R2.1
unnamed: D1.3, R4.1
unnamed: D1.4, R3.1
unnamed: D2.1, R6.1
unnamed: D2.3, R8.1
unnamed: D2.4, R7.1
unnamed: D3.1, R11.1
unnamed: D3.3, R13.1
unnamed: D3.4, R12.1
unnamed: IC1.29, P2.1, R1.2
unnamed: IC1.32, R5.2
unnamed: P11.1, U2.16
unnamed: P11.2, U2.15
unnamed: P12.1, U2.14
unnamed: P12.2, U2.13
unnamed: P19.1, U2.10
unnamed: Q1.1, R5.1, R9.2
VCC: C2.1, C5.1, D4.1, D5.1, D6.1, IC1.4, IC1.6, IC1.18, P3.1, P17.1, P19.2, R1.1, R10.2, U2.9
clunet: P7.1, Q1.2, R9.1, R10.1

## KiCad design PCBs/RoBoC_CameraAdaptor/processed.kicad_pcb

Board: 2 copper layers, 36.8 x 43.8 mm, 6 parts (4 on the bottom side), 18 nets.

Parts:
C1: 1uF; C_1206_HandSoldering
P1: CONN_02X12; Pin_Header_Straight_2x12
P2: CONN_02X09; Pin_Header_Straight_2x09
R1, R2: 4.7k; R_1206_HandSoldering
U1: Oscillator; oscillator

Connections:
+3V3: C1.1, P1.1, P1.15, P2.1, R1.1, R2.1, U1.1, U1.4
/D0: P1.14, P2.16
/D1: P1.13, P2.15
/D2: P1.12, P2.14
/D3: P1.11, P2.13
/D4: P1.10, P2.12
/D5: P1.9, P2.11
/D6: P1.8, P2.10
/D7: P1.7, P2.9
/Href: P1.20, P2.6
/PCLK: P1.6, P2.7
/PWDN: P1.22, P2.18
/RESET: P1.21, P2.17
/SIOC: P1.3, P2.3, R1.2
/SIOD: P1.4, P2.4, R2.2
/VSync: P1.5, P2.5
/XCLK: P1.18, P2.8, U1.3
GND: C1.2, P1.2, P1.16, P2.2, U1.2

## Commit log

2023-03-28 add pcb parsing code, this version only works for kicad file version 5
2023-03-28 extract net routing constraints from net class, now it only works for kicad v5
2023-03-29 cal rotation of pad
2023-03-30 refactor pacb extraction and
2023-03-30 clean wires, vias and pads
2023-03-30 dump wires to kicad segment and view circuit using kicad
2023-03-30 add an example after doing segment and via clean
2023-04-03 refactor and add differential pairs
2023-04-04 parse kicad v6 and extract info
2023-04-07 add example and read me for json data format
2023-04-07 json key explaination
2023-04-07 readme for running script for cleaning up data and extract PCB info
2023-04-07 add argv for PCB cleaner
2023-04-08 update info about the pcb class structure
2023-04-08 add link of ipython
2023-04-09 intial script for rl base env
2023-04-11 initial RL env
2023-04-11 debug rl env
2023-04-11 initial framework for RL-based routing
2023-04-12 Adding our scraping, data, and preliminary extraction code
2023-04-12 Initial commit of local PCB to JSON work
2023-04-12 add RL env for vlsi-dat paper
2023-04-12 add folders for collecting data from different sources
2023-04-12 updated metadata
2023-04-12 19 licenses not found
2023-04-12 added license
2023-04-13 Added netclass, wires, and vias to PCB to JSON
2023-04-13 Updated gitignore
2023-04-13 update .gitgnore and cleanup
2023-04-13 Cleanup
2023-04-13 Directory cleanup
2023-04-13 Clean up
2023-04-13 TODO: can't extract from v6 netclasses well
2023-04-13 add more details for data collections
2023-04-13 update readme for circuit upload and check and revise claen up circuit output path
2023-04-13 add save and load for rl model and debug env
2023-04-15 vlsi-dat work: mcts with no rl model
2023-04-15 rearrange pcb files stroing structure, now all the pcb files are stored folder 'PCBs', within it, there are 3 subfolders, raw (kicad or eagle), cleaned (kicad) and final (json)
2023-04-20 kitspace raw files with updated metadata
2023-04-25 rearrage repo
2023-04-25 add metadata.json
2023-04-25 debug mcts
2023-04-25 mcts loads model policy from rl
2023-04-26 re-org
2023-04-26 save initial pcb matrix and nets to save reset time for rl episodes
2023-04-26 add logs for rl training
2023-04-26 load rl model in mcts rollout
2023-04-26 clean code to save mcts run time
2023-04-26 del isolated pad from kicad file, this is for rule-based router if their 8nput is kicad_file
2023-04-27 new strategy to deal with fill zones and incomplete segment
2023-04-27 debug segment delete
2023-04-30 github top 30 pcb designs (kicad v5 raw files)
2023-05-01 deal with more than 2 layers and more cases when well deigned PCB contains redundant wires
2023-05-01 clean up code by deleting testing part
2023-05-02 debug rl env and clean data for rl
2023-05-03 pcb extract update
2023-05-03 revise file names
2023-05-04 Test
2023-05-04 VC Schenanigans
2023-05-04 Manual Merge-Like Update.
    Some merging shenanigans meant we had to manually bring the files from GBJF-574 to Main, rather than going through a PR.
2023-05-04 Forgot this in last VC clean-up
2023-05-05 Ran KiCad cleaning script, reported errors in error.log
2023-05-12 data conversion from kicad to json
2023-05-12 clean up using new data extraction scripts
2023-05-12 update cleaning runner script and add converted JOSN files and the script to runner the converter
2023-05-13 load data from json for lr, debug data extraction and data conversion.
2023-05-18 recheck all circuits and clean up fill zone by rerouting the nets using freerouting and manually
2023-05-19 rl update
2023-05-19 clean psbc that are missed before
2023-05-19 add wires to replace fill zones of wiggle pcb
2023-05-19 debug extracting differential pair
2023-05-20 initial adding wire with width
2023-05-20 add wires with width for each rl step and debug gridize
2023-05-23 Perform augmentation on all PCB boards.
2023-05-24 Some Preliminary BRD->KiCad for Review
2023-05-29 deal with boundaries extraction with fp_text, and update dataset
2023-05-30 mcts-rl (vlsi-dat work) and debug data extraction
2023-05-30 output mcts results
2023-05-31 debug mcts env and add freerouting runing script
2023-05-31 refactor data loader and add ocb state class for usrers to design their own state
2023-05-31 debug vlsi-dat env from the changes of RL env
2023-06-05 debug mcts-rl and add exp for baselines
2023-06-05 refactor data cleaning code and update readme
2023-06-06 add kicad 6 to 5 convertion
2023-06-06 process two more boards and update dataset
2023-06-06 possible v6 support
2023-06-10 Create LICENSE
2023-06-11 update meta data
2023-06-12 add package installation, and reorg RL env part
2023-06-13 reorg baselines and install paarser
2023-06-13 update readme and add examples of using RL env
2023-06-13 fix url error
2023-06-13 add url of augmentation and delete build files
2023-06-14 update readme of baselines
2023-06-14 add link of results
2023-06-14 update json format and attribute name in PCB_state
2023-06-18 revise final format and its RL loading
2023-08-02 debug data augmentation
2023-08-12 add differential pairs
2023-08-13 debug inconsistent boundary extraction
2023-08-18 add pcb example to readme
2023-08-18 update image link in readme
2023-08-19 update data cleaning and conversion and add 60 more PCBs
2023-08-25 update visualizatiion
2023-08-25 revise pcb visualization
2023-08-27 add pcb images
2023-08-27 update pcb example name
2023-08-27 update pcb images
2023-08-28 add visuals of PCB to each PCB folder
2023-08-30 update PCB clean readme
2023-08-30 update clean data readme
2023-09-01 update cleaning scripts
2023-09-04 update data cleaning
2023-09-04 add PCBs to be processed
2023-09-12 add new PCBs
2023-10-28 update dataset by adding around 1000 PCBs
2023-11-04 update for adding new PCBs
2023-11-05 update reset of rl env for new version of gym and stable baselines
2023-11-12 process exp results
2023-11-13 debug boundaries of PCBs
2023-11-27 processing kicad v7 files
2023-11-27 revise RL env for new json format
2023-11-27 change list net to dict net
